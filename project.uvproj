# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd12864.c lcd12864.h define.h MatrixKey.c MatrixKey.h Delay.c Delay.h AT24C02.c AT24C02.h I2C.c I2C.h DS1302.c DS1302.h DHT11.c DHT11.h GY30.c GY30.h Timer.c Timer.h stepmotor.c stepmotor.h Buzzer.h Buzzer.c OneWire.c OneWire.h DS18B20.c DS18B20.h
